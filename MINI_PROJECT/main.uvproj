# Keil uVision project main.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: main +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group rtc
    ./: Startup.s main.c rtc_define.h
  group lcd
    ./: lcd.h
  group delay
    ./: delay.h
  group types
    ./: types.h
  group switch
    ./: interrupt.c interrput.h
  group keypad
    ./: keypad.h
